# Keil uVision project SX1276.uvprojx, settings and files
target sx12xxDrivers (ARM-ADS)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00014000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SX1276
  AfterMake: fromelf.exe --bin -o .\Objects\SX1276.bin .\Objects\SX1276.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L1XX_HD ,PLATFORM=SX12xxEiger
  c include: .\src\platform\sx12xxEiger;.\src\platform\stm32libs\CMSIS\CM3;.\src\platform\stm32libs\stm32l1xx;.\src\radio;.\src\platform;.\src\platform\stm32libs\stm32l1xx\inc;.\src\usart;.\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group User
    ./src/: main.c
  group radio
    ./src/radio/: radio.c sx1232.c sx1272.c sx1272-Fsk.c sx1272-FskMisc.c sx1272-LoRa.c sx1272-LoRaMisc.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c sx1232-Misc.c
  group sx12xxEiger
    ./src/platform/sx12xxEiger/: fifo.c spi.c sx12xxEiger.c sx1232-Hal.c sx1272-Hal.c sx1276-Hal.c
    ./src/usart/: bsp_usart.c
  group stm32libs-l1xx
    ./src/platform/stm32libs/stm32l1xx/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
    ./src/platform/stm32libs/CMSIS/CM3/: system_stm32l1xx.c
    ./src/: startup_stm32l1xx_xl.s stm32l1xx_it.c
